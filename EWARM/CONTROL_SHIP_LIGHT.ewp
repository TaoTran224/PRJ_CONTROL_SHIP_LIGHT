# IAR project CONTROL_SHIP_LIGHT.ewp, settings and files
configuration CONTROL_SHIP_LIGHT (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../App/Inc; ../Si4432/Inc; ../Common/Inc; ../Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CONTROL_SHIP_LIGHT.hex
  ILINK.IlinkOutputFile: CONTROL_SHIP_LIGHT.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App/Inc
    ../App/Inc/: app.h board.h interrupt.h rf_func.h
  group App/Src
    ../App/Src/: app.c board.c interrupt.c rf_func.c
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: gpio.c iwdg.c main.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c usart.c
  group Common
    ../Common/: inc_def.h
  group Common/Inc
    ../Common/inc/: calculator.h log.h
  group Common/Src
    ../Common/src/: calculator.c log.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Si4432/Inc
    ../Si4432/inc/: si4432.h
  group Si4432/Src
    ../Si4432/src/: si4432.c
