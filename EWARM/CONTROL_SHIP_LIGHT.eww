<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CONTROL_SHIP_LIGHT.ewp</path>
  </project>
  <batchBuild />
</workspace>
